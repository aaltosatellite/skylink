options:
  parameters:
    author: baris
    generate_options: qt_gui
    id: Foresail_1
    output_language: python
    title: Foresil1
  states: {}

blocks:
- name: fsk_deviation_hz
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '500'
    step: '100'
    stop: '20000'
    value: '3000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: samples_per_symbol
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '2'
    step: '1'
    stop: '100'
    value: '26'
  states: {}
- name: shift
  id: variable_qtgui_range
  parameters:
    label: shift
    orient: Qt.Horizontal
    start: '-10000'
    step: '100'
    stop: '10000'
    value: '0'
  states: {}
- name: squelch_threshold
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-90'
    step: '1'
    stop: '0'
    value: '-45'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_hz/8.0)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-40000+shift'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.5'
    threshold: squelch_threshold
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/baris/output.raw
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/baris/output_byte.raw
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/baris/output_float.raw
    type: float
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/baris/gqrx_20210304_122932_437000030_250000_fc.raw
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_0_1
  id: blocks_tag_debug
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: cc11xx_cc11xx_deframer_bb_0
  id: cc11xx_cc11xx_deframer_bb
  parameters:
    has_crc: 'False'
    has_whitening: 'False'
    preamble_bytes: '2'
    sync1: '0xAA'
    sync2: '0xAA'
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samples_per_symbol*(1+0.0)
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_correlate_access_code_tag_xx_0_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '0x352e'
    tagname: preamble
    threshold: '20'
    type: byte
  states: {state: disabled}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '10000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ylabel: Ch2
    ymax: '10'
    ymin: '-10'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ylabel: Ch1
    ymax: '10'
    ymin: '-10'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '250000'
    fc: '0'
    fftsize: '2048'
    int_max: '0'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: satellites_sync_to_pdu_packed_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '300'
    sync: '"00011010110011111111110000011101"'
    threshold: '1'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_const_sink_x_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_0, '1']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0_0, '0']
- [cc11xx_cc11xx_deframer_bb_0, out, blocks_message_debug_0, print]
- [digital_binary_slicer_fb_0, '0', blocks_file_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', cc11xx_cc11xx_deframer_bb_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_tag_xx_0_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_sync_to_pdu_packed_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_file_sink_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_tag_debug_0_1, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [digital_correlate_access_code_tag_xx_0_0, '0', blocks_null_sink_0, '0']
- [digital_correlate_access_code_tag_xx_0_0, '0', blocks_tag_debug_0, '0']
- [low_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [satellites_sync_to_pdu_packed_0, out, blocks_message_debug_0, print_pdu]

metadata:
  file_format: 1
