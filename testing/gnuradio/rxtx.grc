options:
  parameters:
    generate_options: no_gui
    id: suomi100_rxtx
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 437.125e6
  states: {}
- name: demod_samp_rate
  id: variable
  parameters:
    value: '0'
  states: {}
- name: doppler_corrected_freq
  id: variable
  parameters:
    value: center_freq
  states: {}
- name: doppler_shift
  id: variable
  parameters:
    value: doppler_corrected_freq - center_freq
  states: {}
- name: mod_samp_rate
  id: variable
  parameters:
    value: symbol_rate*2
  states: {}
- name: sdr_freq
  id: variable
  parameters:
    value: 435e6
  states: {}
- name: sdr_samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '0.5'
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq - sdr_freq + doppler_shift
    offset: '0'
    phase: '0'
    samp_rate: sdr_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1/8.0
    lengthtagname: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_additive_scrambler_bb_0
  id: digital_additive_scrambler_bb
  parameters:
    bits_per_byte: '1'
    count: '0'
    len: '7'
    mask: '0x9A'
    reset_tag_key: '"packet_len"'
    seed: '0xff'
  states: {state: disabled}
- name: digital_additive_scrambler_bb_0_0
  id: digital_additive_scrambler_bb
  parameters:
    bits_per_byte: '1'
    count: '0'
    len: '7'
    mask: '0xA9'
    reset_tag_key: '"packet_len"'
    seed: '0xFF'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.07'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: int(mod_samp_rate/symbol_rate)
    omega_relative_limit: '0.014'
    type: float
  states: {state: disabled}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '10010011000010110101000111011110'
    tagname: syncword
    threshold: '3'
    type: byte
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.275'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: int(mod_samp_rate/symbol_rate)
  states: {}
- name: digital_gmsk_mod_0_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: int(sdr_samp_rate/symbol_rate)+1
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, preamble_length=42, syncword=0x1A, syncword_length=32):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Append Preamble and Sync word',
                  in_sig=[np.byte],
                  out_sig=[np.byte]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
      	self.preamble_length = preamble_length
              self.syncword = syncword
              self.syncword_length = syncword_length

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    preamble_length: '42'
    syncword: '26'
    syncword_length: '32'
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: doppler_corrected_freq - sdr_freq
    decim: int(sdr_samp_rate / mod_samp_rate)
    samp_rate: sdr_samp_rate
    taps: firdes.low_pass(1, sdr_samp_rate, 2*symbol_rate, symbol_rate/4)
    type: ccf
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: localhost
    gpredict_port: '4532'
    target: doppler_corrected_freq
    verbose: 'True'
  states: {state: disabled}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    comment: |-
      Because wanted sample rate cannot be achieved with 
      Xlating FIR filters integer decimation factor. 
      An additional fractional resampler is needed.

      (sdr_samp_rate / int(sdr_samp_rate / decimated_samp_rate) ) / decimated_samp_rate
    phase_shift: '0'
    resamp_ratio: sdr_samp_rate / (mod_samp_rate * int(sdr_samp_rate / mod_samp_rate) )
    type: complex
  states: {}
- name: mmse_resampler_xx_1
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: (int(sdr_samp_rate/symbol_rate)+1)/(sdr_samp_rate/symbol_rate)
    type: complex
  states: {}
- name: satellites_check_crc_0
  id: satellites_check_crc
  parameters:
    force: 'True'
    include_header: 'True'
  states: {}
- name: satellites_decode_rs_0
  id: satellites_decode_rs
  parameters:
    fcr: '1'
    gfpoly: '285'
    interleave: '1'
    nroots: '1'
    nsym: '8'
    prim: '1'
  states: {}
- name: satellites_encode_rs_0
  id: satellites_encode_rs
  parameters:
    fcr: '1'
    gfpoly: '285'
    interleave: '1'
    nroots: '1'
    nsym: '8'
    prim: '1'
  states: {state: disabled}
- name: satellites_varlen_packet_tagger_0
  id: satellites_varlen_packet_tagger
  parameters:
    endianness: gr.GR_MSB_FIRST
    length_field_size: '12'
    mtu: 255*8
    packetlen_tag: packet_len
    syncword_tag: syncword
    use_golay: 'True'
  states: {}
- name: soapy_sink_0
  id: soapy_sink
  parameters:
    amp_gain0: '0'
    center_freq0: 100.0e6
    dev: driver=leecher
    devname: custom
    iamp_gain0: '0'
    pad_gain0: '0'
    pga_gain0: '24'
    samp_rate: sdr_samp_rate
    txvga1_gain: '-35'
    txvga2_gain: '0'
    type: fc32
    vga_gain0: '10'
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    balance0: '0'
    center_freq0: 100.0e6
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'True'
    dev: driver=leecher
    devname: custom
    overall_gain0: '10'
    samp_rate: sdr_samp_rate
    type: fc32
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:7001
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:6001
    timeout: '100'
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:6001
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', soapy_sink_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_additive_scrambler_bb_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', blocks_tagged_stream_to_pdu_0_0, '0']
- [blocks_tagged_stream_to_pdu_0_0, pdus, satellites_decode_rs_0, in]
- [blocks_unpacked_to_packed_xx_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [digital_additive_scrambler_bb_0, '0', epy_block_0, '0']
- [digital_additive_scrambler_bb_0_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', satellites_varlen_packet_tagger_0, '0']
- [digital_gmsk_demod_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_gmsk_mod_0_0, '0', mmse_resampler_xx_1, '0']
- [epy_block_0, '0', digital_gmsk_mod_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [mmse_resampler_xx_0, '0', digital_gmsk_demod_0, '0']
- [mmse_resampler_xx_1, '0', blocks_multiply_xx_0, '0']
- [satellites_check_crc_0, ok, zeromq_pub_msg_sink_0, in]
- [satellites_decode_rs_0, out, satellites_check_crc_0, in]
- [satellites_encode_rs_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [satellites_varlen_packet_tagger_0, '0', digital_additive_scrambler_bb_0_0, '0']
- [soapy_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [zeromq_sub_msg_source_0, out, satellites_encode_rs_0, in]
- [zeromq_sub_source_0, '0', digital_gmsk_mod_0_0, '0']

metadata:
  file_format: 1
